## ESP_IOT_demotest/main/sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="Xiaomi_9DCE"
CONFIG_EXAMPLE_WIFI_PASSWORD="cht20060717.."
```
